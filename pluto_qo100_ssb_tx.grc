options:
  parameters:
    author: RA4HGN
    category: Custom
    description: SSB transciever for pluto
    generate_options: qt_gui
    id: qo_100_trcvr
    output_language: python
    title: SSB TRANSCEIVER FOR PLUTO
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '739750000'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: TX FREQ
    start: '10489500000'
    step: '100'
    stop: '10489990000'
    value: '10489680000'
  states: {}
- name: hcf
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,2
    label: HCF
    label0: '1000'
    label1: '2700'
    label2: '3400'
    num_opts: '3'
    option0: '1000'
    option1: '2700'
    option2: '3400'
    orient: Qt.QHBoxLayout
    type: int
    value: '2700'
  states: {}
- name: lcf
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,1
    label: LCF
    label0: '0'
    label1: '100'
    label2: '200'
    num_opts: '3'
    option0: '1'
    option1: '100'
    option2: '200'
    orient: Qt.QHBoxLayout
    type: int
    value: '1'
  states: {}
- name: lnb_lo
  id: variable
  parameters:
    value: '9749972630'
  states: {}
- name: offset
  id: variable
  parameters:
    value: '7320'
  states: {}
- name: oscillator
  id: variable_qtgui_range
  parameters:
    label: OSCILLATOR LEVEL
    start: '0.1'
    step: '0.1'
    stop: '10'
    value: '1.5'
  states: {}
- name: rf_input
  id: variable_qtgui_range
  parameters:
    label: TX INPUT
    start: '0.1'
    step: '0.1'
    stop: '10'
    value: '6.5'
  states: {}
- name: rx_samp_rate
  id: variable
  parameters:
    value: '512000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: tx_att
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0
    label: TX ATT
    label0: '10'
    label1: '15'
    label2: '20'
    label3: '0'
    num_opts: '4'
    option0: '10'
    option1: '15'
    option2: '20'
    option3: '0'
    orient: Qt.QHBoxLayout
    type: real
    value: '10'
  states: {}
- name: tx_rx
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,4
    label: TX/RX
    label0: RX
    label1: TX
    num_opts: '2'
    option0: '0'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: oscillator
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: '192000'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: hcf
    low_cutoff_freq: lcf
    samp_rate: '48000'
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: hcf
    low_cutoff_freq: lcf
    samp_rate: '48000'
    type: fir_filter_ccc
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: rf_input
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_rx
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    maxoutbuf: '100'
    minoutbuf: '10'
    num_taps: '512'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_att
    bandwidth: '20000000'
    buffer_size: '3276800'
    comment: fre:5176280000
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: freq - 8089500000 - offset
    samplerate: samp_rate
    type: fc32
    uri: uri
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: '2400170000'
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: '256000'
    type: fc32
    uri: uri
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '2400170000'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '6'
    interp: '24'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '192000'
    interp: '4000000'
    taps: ''
    type: ccc
  states: {}
- name: uri
  id: parameter
  parameters:
    label: URI
    type: str
    value: ip:pluto.local
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [audio_source_0, '0', blocks_multiply_const_vxx_2, '0']
- [band_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [band_pass_filter_0_0, '0', rational_resampler_xxx_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', iio_pluto_sink_0, '0']
- [blocks_multiply_const_vxx_2, '0', band_pass_filter_0, '0']
- [blocks_multiply_xx_0, '0', band_pass_filter_0_0, '0']
- [hilbert_fc_0, '0', blocks_multiply_xx_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', hilbert_fc_0, '0']
- [rational_resampler_xxx_1, '0', blocks_multiply_const_vxx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
